# Keil uVision project Main.uvprojx, settings and files
target N32G45x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G455CCL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32g45x_std_periph_driver\inc;..\WS1850;..\compoennts\RTT\Config;..\compoennts;..\compoennts\RTT\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_dac.c n32g45x_dma.c n32g45x_exti.c n32g45x_gpio.c n32g45x_iwdg.c n32g45x_pwr.c n32g45x_rcc.c n32g45x_tim.c n32g45x_usart.c n32g45x_flash.c
  group USER
    ../src/: main.c ble_protocol.c n32g45x_it.c init.c delay.c tm1621c.c AppHandle.c
  group COMP
    ../compoennts/RTT/src/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group DOC
    ../: readme.txt
